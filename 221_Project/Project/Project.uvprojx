# Keil uVision project Project.uvprojx, settings and files
target GD32E230C_START (6210000::V6.21::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230C_START +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\Firmware\GD32E23x_standard_peripheral\Include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32E23x\Include;..\User;..\Hardware;..\Hardware\usart;..\Hardware\cmt2119b;..\Hardware\cmt2219b;.\App;..\Hardware\rf_config;..\Hardware\common;..\Hardware\common;..\interface
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: gd32e23x_it.c main.c systick.c main.h
  group Hardware
    ../Hardware/usart/: bsp_usart.c bsp_usart.h
    ../Hardware/cmt2119b/: cmt2119b.c cmt2119b.h cmt2119b_params.h cmt2119b_port.c cmt2119b_port.h cmt2119b_spi.c cmt2119b_spi.h radio_tx.c radio_tx.h
    ../Hardware/cmt2219b/: cmt2219b.c cmt2219b.h cmt2219b_params.h cmt2219b_port.c cmt2219b_port.h cmt2219b_spi.c cmt2219b_spi.h radio_rx.c radio_rx.h
    ../Hardware/common/: Debug_printf.c Debug_printf.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
    ../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group App
    ./App/: app_211.c app_211.h app_221.c app_221.h led_test.c led_test.h app_tx-rx_config.c app_tx-rx_config.h app_key.c app_key.h packet_loss_test.c packet_loss_test.h
  group Firmware
    ../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Doc
    ../Doc/: readme.txt
  group rf_config
    ../Hardware/rf_config/: rf_apply.c rf_config.c rf_config.h rf_apply.h rf_uart_set_config.c rf_uart_set_config.h
  group interface
    ../interface/: bsp_wired.c bsp_wired.h
software components: CMSIS:CORE 5.0.2
